# Keil uVision project elm329.uvprojx, settings and files
target adapter (ARM-ADS)
  device: STM32F042K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: obdst16
  c flags: Optim=3 wLevel=2
  c misc: -DHSE_VALUE=12000000
  c include: .\src\drv\stm32f0xx;.\src\util;.\STM32F0xx_StdPeriph_Driver\inc;.\src\adapter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group app
    ./src/adapter/: adapter.cpp adapterconfig.cpp dispatcher.cpp functions.cpp
    ./src/util/: algorithms.cpp canmsgbuffer.cpp lstring.cpp
  group driver
    ./src/drv/stm32f0xx/: AdcSTM32F0xx.cpp CanDriverSTM32F0xx.cpp CmdUartSTM32F0xx.cpp GpioDrvSTM32F0xx.cpp SysutilitySTM32F0xx.cpp TimerSTM32F0xx.cpp led.cpp
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_can.c stm32f0xx_adc.c
  group obd
    ./src/adapter/obd/: autoadapter.cpp canhistory.cpp isocan.cpp obdprofile.cpp padapter.cpp
  group ::Device
    RTE/Device/STM32F042K6/: startup_stm32f042.s system_stm32f0xx.c
software components: CMSIS:CORE 4.2.0, Device:Startup 1.5.0
